# Keil uVision project MovingLabyrinth.uvprojx, settings and files
target KL05Z (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Cw_1
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group src
    ./: i2c.c lcd1602.c main.c analog_controller.c servo_controller.c sensor_controller.c utils.c
  group include
    ./: analog_controller.h servo_controller.h sensor_controller.h ADC_CONSTANTS.h utils.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
